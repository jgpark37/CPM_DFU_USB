<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CPM_DFU_USB.ewp</path>
  </project>
  <batchBuild />
</workspace>
